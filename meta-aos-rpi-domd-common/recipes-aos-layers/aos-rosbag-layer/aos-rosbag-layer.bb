SUMMARY = "rosbag layer"

require recipes-aos-layers/aos-base-layer/aos-base-layer.inc

AOS_LAYER_FEATURES += " \
    rosbag2 \
"
