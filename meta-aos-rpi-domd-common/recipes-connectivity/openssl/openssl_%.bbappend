HSM_MODULE_PATH = "${libdir}/libckteec.so.0"
