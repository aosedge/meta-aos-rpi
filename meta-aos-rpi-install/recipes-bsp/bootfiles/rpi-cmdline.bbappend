CMDLINE_AOS_DISK ?= ""

CMDLINE:append = " \
   aos_disk=${CMDLINE_AOS_DISK} \
"
