CMDLINE_AOS_DISK ?= ""
 
CMDLINE:append = " \
    ${CMDLINE_AOS_DISK} \
"
