IMAGE_FSTYPES = "rpi-sdimg"

inherit core-image
